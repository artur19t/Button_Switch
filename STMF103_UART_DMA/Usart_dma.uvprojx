# Keil uVision project Usart_dma.uvprojx, settings and files
target F103C8T6 (6240000::V6.24::ARMCLANG)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Usart_dma
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group App
    ./: main.c main.h
  group User
    ./: hw_init.c hw_init.h it.c it.h usart_logic.c usart_logic.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
